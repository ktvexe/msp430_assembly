<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\F64011279_P1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\P1_1\F64011279_P1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


